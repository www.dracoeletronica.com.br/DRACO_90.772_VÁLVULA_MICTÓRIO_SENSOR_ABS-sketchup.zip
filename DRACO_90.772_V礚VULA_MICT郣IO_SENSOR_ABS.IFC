Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_90.772_VÁLVULA_MICTÓRIO_SENSOR_ABS.IFC
Time: 2023-06-19T18:57:38
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
